# Keil uVision project SabanWi_Master.uvprojx, settings and files
target SabanWi_Master (6220000::V6.22::ARMCLANG)
  device: NUC220LE3AN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: SabanWi_Master +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6LangP=2
  c include: ..\..\Drivers\CMSIS\Include;..\..\Drivers\Device\Nuvoton\NUC200Series\Include;..\..\Drivers\StdDriver\inc;..\..\App;..\..\Core\inc;..\..\App\HID_Transfer\inc;..\..\Middlewares\Usb_Hid\inc;..\..\Middlewares\DataFlash\inc;..\..\Middlewares\LoRa_Phy\App;..\..\Middlewares\LoRa_Phy\Target;..\..\Security\inc;..\..\App\RF_Transfer\inc;..\..\App\Operation\inc;..\..\App\GPIO_Control\inc;..\..\Middlewares\Modbus_Master\App;..\..\Middlewares\Modbus_Master\Target;..\..\Middlewares\Modbus_Slave\App;..\..\Middlewares\Modbus_Slave\Target\modbus_src\include;..\..\Middlewares\Modbus_Slave\Target\modbus_src\rtu;..\..\Middlewares\Modbus_Slave\Target\port_src;..\..\App\Master_main;..\..\Core\inc\Master_GPIO_Driver
  asm include: ..\..\Drivers\CMSIS\Include;..\..\Drivers\Device\Nuvoton\NUC200Series\Include;..\..\Drivers\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App/MDK-ARM
    ../../Drivers/Device/Nuvoton/NUC200Series/Source/ARM/: startup_NUC200Series.s
  group App/User/Core/main
    ../../App/Master_main/: main.c
  group App/User/Core/driver_init
    ../../Core/src/: systerm.c spi_driver.c uart_driver.c usb_driver.c wdt_driver.c timer_driver.c dataflash_driver.c
    ../../Core/src/Master_GPIO_Driver/: gpio_driver.c
  group App/User/Core/driver_irq
    ../../Core/src/: wdt_driver_irq.c uart_driver_irq.c
    ../../Core/src/Master_Timer_Driver_Irq/: timer_driver_irq.c
  group App/User/Operation
    ../../App/Operation/src/: operation.c
  group App/User/HID_Transfer
    ../../App/HID_Transfer/src/: descriptors.c hid_transfer.c
  group App/User/RF_Transfer
    ../../App/RF_Transfer/src/: RF_Transfer.c
  group App/User/GPIO_Control
    ../../App/GPIO_Control/src/: gpio_control.c
  group Drivers/NUC220_StdDriver
    ../../Drivers/StdDriver/src/: clk.c fmc.c gpio.c retarget.c spi.c sys.c timer.c uart.c wdt.c usbd.c
  group Drivers/CMSIS
    ../../Drivers/Device/Nuvoton/NUC200Series/Source/: system_NUC200Series.c
  group Middleware/USB_Stack
    ../../Middlewares/Usb_Hid/src/: usb_stack.c
  group Middleware/DataFlash_Stack
    ../../Middlewares/DataFlash/src/: DataFlash_stack.c
  group Middleware/Lora_Phy/App
    ../../Middlewares/LoRa_Phy/App/: radio.c SX1278.c SX1278-Fsk.c SX1278-LoRa.c
  group Middleware/Lora_Phy/Target
    ../../Middlewares/LoRa_Phy/Target/: SX1278_HW.c SX1278Fsk_Misc.c SX1278LoRa_Misc.c
  group Security
    ../../Security/src/: aes.c des.c hmac.c sha.c crc_modbus.c
  group Middleware/Modbus_Master/App
    ../../Middlewares/Modbus_Master/App/: modbus_master.c ringbuffer.c
  group Middleware/Modbus_Master/Target
    ../../Middlewares/Modbus_Master/Target/: bsp_board.c trans_recieve_buff_control.c
  group Middleware/Modbus_Slave/App
    ../../Middlewares/Modbus_Slave/App/: Modbus_User.c
  group Middleware/Modbus_Slave/Target
    ../../Middlewares/Modbus_Slave/Target/modbus_src/: mb.c
    ../../Middlewares/Modbus_Slave/Target/modbus_src/rtu/: mbcrc.c mbrtu.c
    ../../Middlewares/Modbus_Slave/Target/modbus_src/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncinput.c mbfuncother.c mbfuncholding.c mbutils.c
    ../../Middlewares/Modbus_Slave/Target/port_src/: port.c portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 6.1.0
