# Keil uVision project rf_client.uvprojx, settings and files
target rf_client (6220000::V6.22::ARMCLANG)
  device: NUC220LE3AN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: rf_client +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6LangP=2 wLevel=3
  c include: ..\..\app_project_rf\main\inc;..\..\app_project_rf\gpio_control\inc;..\..\app_project_rf\hid_transfer\inc;..\..\app_project_rf\packet_rf\inc;..\..\app_project_rf\packet_rf\security\inc;..\..\bsp_source\inc;..\..\cpu_source\CMSIS\Include;..\..\cpu_source\Device\Nuvoton\NUC200Series\Include;..\..\cpu_source\StdDriver\inc;..\..\driver_source\driver_dataFlash\inc;..\..\driver_source\driver_lora\App;..\..\driver_source\driver_lora\Target;..\..\driver_source\driver_modbus_master\App;..\..\driver_source\driver_modbus_master\Target;..\..\driver_source\driver_modbus_slave\App;..\..\driver_source\driver_modbus_slave\Target\modbus_src\include;..\..\driver_source\driver_modbus_slave\Target\modbus_src\rtu;..\..\driver_source\driver_modbus_slave\Target\port_src;..\..\driver_source\driver_usb_hid\inc;..\..\Utilities\Log
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app/main
    ../../app_project_rf/main/src/: main.c operation.c
  group app/packet
    ../../app_project_rf/packet_rf/src/: RF_Transfer.c
    ../../app_project_rf/packet_rf/security/src/: aes.c crc_modbus.c des.c hmac.c sha.c
  group app/hid
    ../../app_project_rf/hid_transfer/src/: descriptors.c hid_transfer.c
  group app/gpio_control
    ../../app_project_rf/gpio_control/src/: gpio_control.c
  group bsp_nuc220
    ../../bsp_source/src/: dataflash_driver.c gpio_driver.c spi_driver.c systerm.c timer_driver.c timer_driver_irq.c uart_driver.c uart_driver_irq.c usb_driver.c wdt_driver.c wdt_driver_irq.c
  group cpu_nuc220
    ../../cpu_source/Device/Nuvoton/NUC200Series/Source/: system_NUC200Series.c
    ../../cpu_source/Device/Nuvoton/NUC200Series/Source/ARM/: startup_NUC200Series.s
    ../../cpu_source/StdDriver/src/: clk.c fmc.c gpio.c retarget.c spi.c sys.c timer.c uart.c usbd.c wdt.c
  group driver_nuc220/dataflash
    ../../driver_source/driver_dataFlash/src/: DataFlash_stack.c
  group driver_nuc220/lora/app
    ../../driver_source/driver_lora/App/: radio.c SX1278.c SX1278-Fsk.c SX1278-LoRa.c
  group driver_nuc220/lora/target
    ../../driver_source/driver_lora/Target/: SX1278_HW.c SX1278Fsk_Misc.c SX1278LoRa_Misc.c
  group driver_nuc220/modbus_master/app
    ../../driver_source/driver_modbus_master/App/: modbus_master.c ringbuffer.c
  group driver_nuc220/modbus_master/target
    ../../driver_source/driver_modbus_master/Target/: bsp_board.c trans_recieve_buff_control.c
  group driver_nuc220/modbus_slave/app
    ../../driver_source/driver_modbus_slave/App/: Modbus_User.c
  group driver_nuc220/modbus_slave/target
    ../../driver_source/driver_modbus_slave/Target/modbus_src/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../driver_source/driver_modbus_slave/Target/modbus_src/rtu/: mbcrc.c mbrtu.c
    ../../driver_source/driver_modbus_slave/Target/modbus_src/: mb.c
    ../../driver_source/driver_modbus_slave/Target/port_src/: port.c portevent.c portserial.c porttimer.c
  group driver_nuc220/usb_hid
    ../../driver_source/driver_usb_hid/src/: usb_stack.c
  group utility
    ../../Utilities/Log/: log.c
software components: CMSIS:CORE 6.1.0
